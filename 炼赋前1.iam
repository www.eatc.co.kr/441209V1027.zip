# Autodesk Inventor assembly: 조립품1
## iProperties
Created: 2014-12
Part Number: 조립품1
Document SubType Name: Assembly
Designer: tw_037
Author: tw_037
